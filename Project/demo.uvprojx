# Keil uVision project demo.uvprojx, settings and files
target STM32F407-uCOSIII (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOSIII_STM32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Stm32f4xxlib_v_1_4\inc;..\User;..\Core;..\System\delay;..\System\usart;..\System\sys;..\App\led;..\UcosIII\uC-LIB;..\UcosIII\uC-CPU;..\UcosIII\uCOS-III;..\UcosIII\UCOS_BSP;..\UcosIII\uCOS_CONFIG;..\UcosIII\uCOS-III\Source;..\UcosIII\uC-CPU\ARM-Cortex-M4\RealView;..\UcosIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UcosIII\uC-LIB\Ports\ARM-Cortex-M4\RealView
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Log
    ../Log/: log.txt
  group Core
    ../Core/: startup_stm32f40_41xxx.s
  group Lib
    ../Stm32f4xxlib_v_1_4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group led
    ../App/led/: user_led.c
  group UCOSIII_BSP
    ../UcosIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UcosIII/uC-CPU/: cpu_core.c
    ../UcosIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UcosIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UcosIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UcosIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UcosIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UcosIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group README
    ../: README.TXT
